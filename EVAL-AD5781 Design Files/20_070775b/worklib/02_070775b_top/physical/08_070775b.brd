# Allegro board 08_070775b.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
VDD on TOP: 106.17,42.12 106.17,36.82 109.66,36.82 109.66,37.56 109.11,38.11 109.11,38.63 107.75,38.63 107.17,39.21 107.17,40.4 107.01,40.56 107.01,42.12
VDD on L4_PWR: 66.61,65.61 66.61,29.51 93.91,29.51 93.91,35.01 79.41,35.01 79.01,35.41 79.01,41.11 78.16,41.96 72.46,41.96 72.31,42.11 72.31,46.51 75.3,46.51 75.3,57.01 87.01,57.01 87.01,42.81 85.51,42.81 85.51,39.31 92.51,39.31 92.51,42.11 104.31,42.11 104.31,36.81 110.31,36.81 110.31,44.71 99.61,44.71 99.61,51.21 103.81,51.21 103.81,49.71 120.61,49.71 120.61,58.11 126.11,58.11 126.11,45.01 119.11,45.01 119.11,32.71 139.5,32.71 139.5,74.5 116.11,74.5 116.11,52.4 105.51,52.4 105.51,65.61
VSS on TOP: 116.11,39.75 116.11,38.25 110.67,38.25 110.31,38.61 110.31,41.51 113.11,41.51 113.11,40.11 113.48,39.75
VSS on TOP: 104.64,45.4 104.64,46.82 105.18,47.37 105.18,52.21 102.81,52.21 102.81,45.4
VSS on TOP: 87.9,43.45 87.9,44.87 88.44,45.41 88.44,50.21 85.91,50.21 85.91,47.51 86.71,46.71 86.71,43.45
VSS on L4_PWR: 72.81,46.01 72.81,42.61 78.61,42.61 79.51,41.71 79.51,35.81 79.81,35.51 94.41,35.51 94.41,32.71 116.01,32.71 116.01,49.21 103.31,49.21 103.31,50.71 100.11,50.71 100.11,45.21 110.81,45.21 110.81,36.31 103.81,36.31 103.81,41.61 93.01,41.61 93.01,38.81 85.01,38.81 85.01,43.31 86.51,43.31 86.51,56.51 75.8,56.51 75.8,46.01
ARD_5V on TOP: 44,58.45 44,57.3 43.3,57.3 43.3,55.9 44.4,55.9 45.5,54.8 46.9,54.8 46.9,58.45
ARD_5V on L4_PWR: 32.71,74.5 32.71,29.51 66.11,29.51 66.11,66.11 106.01,66.11 106.01,52.9 115.61,52.9 115.61,74.5
ARD_VLOGIC on L4_PWR: 121.11,57.61 125.61,57.61 125.61,45.51 118.61,45.51 118.61,32.21 139.5,32.21 139.5,0.5 125.91,0.5 125.91,20.81 94.11,20.81 94.11,29.01 94.41,29.01 94.41,32.21 116.51,32.21 116.51,49.21 121.11,49.21
EXT_VDD on TOP: 22.1,66 22.1,63.6 28.81,63.6 28.81,66
EXT_VDD on L4_PWR: 22.1,66 22.1,55.7 28.7,55.7 28.7,66
EXT_VSS on TOP: 12.09,66 12.09,63.6 18.81,63.6 18.81,66
EXT_VSS on L4_PWR: 12.09,66 12.09,55.7 18.69,55.7 18.69,66
LDO_VDD on TOP: 70.5,66.2 70.5,62.7 75.2,62.7 75.2,64.6 74.2,64.6 74,64.8 74,66.2
LDO_VSS on TOP: 70.2,58.1 70.2,57.4 69.5,56.7 68.9,56.7 68.9,55.1 72.2,55.1 72.2,56.7 71.3,56.7 70.6,57.4 70.6,58.1
UNNAMED_5_ADP5070_I35_INBK on TOP: 43.3,61.4 43.3,60.4 43.7,60.4 44.1,60.8 46.9,60.8 48.01,61.91 48.01,70.6 45,70.6 45,62.2 44.2,61.4
UNNAMED_5_ADP5070_I35_SW1 on TOP: 44,60.3 44,59.8 48.8,59.8 50.6,61.6 54.3,61.6 54.3,63.6 52.8,63.6 51.8,64.6 51.8,70.6 48.91,70.6 48.91,62.21 47.2,60.5 44.2,60.5
UNNAMED_5_ADP5070_I35_SW2 on TOP: 44,59.05 44,58.7 57.1,58.7 57.1,61.35 50.75,61.35 48.9,59.5 45.5,59.5 45.05,59.05
UNNAMED_5_ADP7118V3_I94_EN on TOP: 64.5,65.9 64.5,63.7 64.7,63.5 66.8,63.5 66.8,66.1 64.7,66.1
UNNAMED_5_ADP7118V3_I94_EN on TOP: 66.8,69.1 66.8,67.7 61.7,67.7 61.7,69.1
UNNAMED_5_ADP7118V3_I94_SENSE on TOP: 70.5,67.7 70.5,66.5 75.5,66.5 75.5,67.7
UNNAMED_5_ADP7118V3_I94_SS on TOP: 66.8,67.4 66.8,66.4 64.6,66.4 64.3,66.1 63.2,66.1 63.2,67.4
UNNAMED_5_ADP7182V5_I95_EN on TOP: 67.8,62.2 67.8,59.4 69.2,59.4 70.2,58.4 71.3,58.4 71.5,58.2 71.5,57.3 71.9,57.3 71.9,59.2 70.9,59.2 70.6,59.5 70.6,62.2
UNNAMED_5_CAP_I60_N1 on TOP: 52.1,70.6 52.1,64.7 52.9,63.9 54.6,63.9 54.6,61.6 56.71,61.6 56.71,70.6
UNNAMED_5_CAP_I61_N1 on TOP: 57.61,70.6 57.61,62.5 61.2,62.5 61.2,70.6
UNNAMED_5_CAP_I79_N1 on TOP: 63.21,62.2 63.21,56.2 67.5,56.2 67.5,62.2
UNNAMED_5_CAP_I80_N1 on TOP: 61.71,62.2 61.71,56.2 57.4,56.2 57.4,62.2
UNNAMED_5_CN3P_I3_N1 on TOP: 21.4,63.6 21.4,67 22.2,67.8 22.2,71.8 19.4,71.8 19.4,63.6
UNNAMED_5_CN3P_I3_N3 on TOP: 11.39,63.6 11.39,67 12.19,67.8 12.19,71.8 9.39,71.8 9.39,63.6

## Text on the board
User.Comments: COMPONENTS GREATER THAN 1.5MM | COMPONENT KEEPOUT AREA | 2.    REPAIRS PER IPC-7711/21(LATEST REVISION) ARE ALLOWED. | 3.    REPAIRS ARE NOT ALLOWED IN SOLDERMASK FREE AREAS ON EITHER | SIDE OF THE BOARD. | 4.    RoHS COMPLIANCE: ASSEMBLY VENDOR SHOULD ASSURE COMPLIANCE | WITH LEAD-FREE AND RoHS PCB ASSEMBLY STANDARDS (EU RoHS | 5.    BOARDS TO BE SHIPPED SINGULATED AFTER ASSEMBLY PROCESS. | 6.    SMOOTHEN EDGES AND FREE FROM BURRS AFTER DEPANELIZATION PROCESS. | DIRECTIVE 2002/95/EC). | 7.    DO NOT TRIM/CUT EXCESS TAIL LENGTH FOR P1, P2, P3, AND P4. | 8.    INSTALL SHUNT CONNECTOR (M031256) TO THE FOLLOWING JUMPERS: | 9.    INSTALL SCREW (M025339) ON PRIMARY SIDE AND | WIRE ENTRY | LK1 - INSTALLED | LK2 - PIN 1 AND PIN 2 | LK3 - PIN 1 AND PIN 2 | STANDOFF (M057696) ON THE SECONDARY SIDE. | SEE NOTE #9 (6 PLACES)
Ref Des/Assembly Top: 1 | C | A
Ref Des/Silkscreen Top: 1 | C | A | 08-070775 REV B Z | EVAL-AD57X1ARDZ | PRIMARY SIDE
PAGE_OUTLINE: B | ECR-114838 | 19JUN23 | J. PABALAN | CUSTOMER EVALUATION Z
DIMENSION: " " | (REF) | DIA MAX | -
User.10: L2 Internal GND | 08-      -07
User.11: L3 Internal GND | 08-      -08
User.13: ROHS COMPLIANCE | NOTE; | 15.    BOARDS TO BE SHIPPED IN ARRAYS AND KEEP INTACT. | 16.    PANELED SOLDER PASTE STENCIL SHOULD BE SENT TO THE CUSTOMER. | 17.    PANEL TO BE SUBJECTED TO CUSTOMER'S APPROVAL.
User.17: L2 GND | 08-      -06
User.18: L3 SIG | 08-      -07
User.19: L4 PWR | 08-      -08
User.20: L5 GND | 08-      -09
User.37: PER ECR-094468 | B | 28MAY20 | PD
User.39: TEMPLATE NOTES. | 01.COMPONENTS ARE PLACED ON THIS SIDE. | 02.CONNECTORS P1,P2.P4 & P5 ARE PLACED | ON THIS SIDE OF THE BOARD. | 03.IF THE BOARD NEEDS TO BE INCREASED | IT CAN BE INCREASED IN THE DIRECTION | OF THE ARROWS. | 04.THE BOARD IS SET-UP AS A 4 LAYER | BOARD. MAKE SURE ANY SUBSEQUENT CHANGES, | MANUAL OR AUTOMATIC, DO NOT RESULT IN | ANY UNINTENDED CONSEQUENCES. | 05.THE EXISTING ROUTING CAN BE ALTERED AS | IS ROUTED TO CLOSE THE NETS ON THE | TEMPLATE BOARD. | PAGE 1 OF 5 | TOP SIDE VIEW | VIEW OF SILKSCREEN, PINS, VIAS, | ETCH AND REFERENCE INFORMATION.
User.40: TEMPLATE NOTES. | 01.COMPONENTS ARE PLACED ON THIS SIDE. | 02.CONNECTORS P3 IS PLACED ON THIS SIDE. THE | OTHER CONNECTORS ARE SOLDERED THIS SIDE. | 03.THE TEMPLATE IS VIEWED LOOKING FROM THE | TOP SIDE OF THE BOARD. THE RESULT IS | THAT TEXT IS MIRRORED. | 04.THE BOARD IS SET-UP AS A 4 LAYER | BOARD. MAKE SURE ANY SUBSEQUENT CHANGES, | MANUAL OR AUTOMATIC, DO NOT RESULT IN | ANY UNINTENDED CONSEQUENCES. | PAGE 2 OF 5 | BOTTTOM SIDE VIEW | VIEW OF SILKSCREEN, PINS, VIAS, | ETCH AND REFERENCE INFORMATION.
User.41: PAGE 3 OF 5 | PCB FAB SHEET 1 | NCDRILL LEGEND, APPROPRIATE | DETAILS AND OUTLINE DIMENSION NOTES. | 01. EACH TIME THE NC DRILL LEGEND | IS RUN, THE HOLE CHART MUST BE | CHECKED TO ASSURE THE TOLERANCES | & NOTES CORRESPOND TO THE RIGHT | PADSTACKS.
User.42: PAGE 4 OF 5 | PCB FAB SHEET 2 | FABRICATION NOTES. ALTER DEPENDING ON THE | REQUIREMENTS OF THE DESIGN.
User.43: PROPERTIES FOR PCB DESIGN USE. | THEY MAINTAIN A SEPARATE TITLE BLOCK AND PART | NUMBER FOR REVISION TRACKING, INDEPENDENT OF | THE ACTUAL MANUFACTURED DUT-SPECIFIC BOARD | DESIGN. | TEMPLATE BOARDS DISPLAY AS "FILE VIEWS", AND | DUT-SPECIFIC APPLICATION BOARDS ARE | MANUFACTURED FROM ARTWORK "FILM VIEWS"AND NC | DATA. | AND TITLE BLOCK CONTENT IS TRACKING THE | MANUFACTURED BOARD PART NUMBER AND REV, | AND NOT THE TEMPLATE BOARD PART NUMBER AND | REV. | MAKE SURE THE DUT-SPECIFIC BOARD INFORMATION | REV.A (20APR20) | 1. INITIAL RELEASE. | TEMPLATE REVISION HISTORY | TEMPLATE BOARDS FOR EVAL PROVIDE INFORMATION IN THE | 5-VIEW "PDF FORMAT" FOR EVAL ENGINEERING | REFERENCE; ALONG WITH EMBEDDED ALLEGRO | PAGE 5 OF 5 | REV.B (28MAY20) PER ECR-094468 | 1. BRING FILES INTO TEMPLATE FORMAT.
User.45: 1 | FABRICATION | 09-012345-01 | A | FIGURE | SIZE | 0.254 | 0.762 | 1.016 | 1.143 | 1.1684 | 1.27 | 1.6002 | 1.7018 | 3.175 | DRILL CHART: TOP to BOTTOM | FINISHED HOLES IN MILLIMETERS | PLATED | NON-PLATED | QTY | 305 | 27 | 20 | 50 | 2 | 3 | 7 | 8 | 6 | TOLERANCE/NOTES
